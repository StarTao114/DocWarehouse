# Keil uVision project NRF_24L01_BASE.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: lora +hex
  c flags: Optimize=6
  c include: .\APP\base;.\APP\LoRa;.\APP\uart;.\APP\MidWare;.\APP\numTools;.\APP\sensor
  group main
    ./: MAIN.C
  group BSP
    ./APP/LoRa/: sx1278.c
    ./APP/uart/: uart.c
    ./APP/base/: gpio.c
  group Application
    ./APP/LoRa/: lora.c
    ./APP/sensor/: sensor.c
  group Midware
    ./APP/base/: delay.c
    ./APP/MidWare/: synchron.c
    ./APP/numTools/: numtools.c
